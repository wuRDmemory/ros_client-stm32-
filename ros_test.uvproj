# Keil uVision project ros_test.uvproj, settings and files
target ros_test (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: geometry +hex
  c flags: Optim=1 wLevel=1
  c define: STM32_f4xx,USE_STDPERIPH_DRIVER, __FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM
  c misc: --cpp
  c include: .\App;.\Bsp;.\CMSIS;.\CMSIS\include;.\Math;.\ros_lib;.\STM32F4xx_StdPeriph_Driver\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group start
    ./CMSIS/: startup_stm32f4xx.s
  group user
    ./User/: includes.h main.c ros.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h Stm32Hardware.h system.c system.h
  group bsp
    ./Bsp/: bsp.c bsp.h usart3.c usart3.h
  group app
    ./App/: app.c app.h
  group cmsis
    ./CMSIS/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group lib
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group roslib
    ./ros_lib/: duration.cpp time.cpp
  group math
    ./Math/: fast_math.c fast_math.h mv_math.c mv_math.h
